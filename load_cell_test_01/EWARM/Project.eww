<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\load_cell_test_01.ewp</path>
  </project>
  <batchBuild />
</workspace>
